## boards/shields/nrf52/Kconfig.defconfig
```kconfig
if SHIELD_NRF52

config ZMK_KEYBOARD_NAME
    default "test_board"

endif # SHIELD_NRF52
```
